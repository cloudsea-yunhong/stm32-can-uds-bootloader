# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (6240000::V6.24::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -Wno-unused-parameter
  c include: ..\Core\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\STM32F4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./: startup_stm32f407xx.s
  group Core
    ../Core/Src/: main.c stm32f4xx_it.c system_stm32f4xx.c bsp_uart.c bsp_can.c flash_if.c params.c boot.c isotp.c uds.c
  group HAL
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c
